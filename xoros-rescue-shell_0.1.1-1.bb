# Auto-Generated by cargo-bitbake 0.3.16
#
inherit cargo

# If this is git based prefer versioned ones if they exist
# DEFAULT_PREFERENCE = "-1"

# how to get xoros-rescue-shell could be as easy as but default to a git checkout:
# SRC_URI += "crate://crates.io/xoros-rescue-shell/0.1.1-1"
SRC_URI += "git://git@github.com/xoros-repo/xoros-rescue-shell.git;protocol=ssh;nobranch=1;branch=main"
SRCREV = "424d3170676f6635361416a5b27324a3d200e449"
S = "${WORKDIR}/git"
CARGO_SRC_DIR = ""
PV:append = ".AUTOINC+424d317067"

# please note if you have entries that do not begin with crate://
# you must change them to how that package can be fetched
SRC_URI += " \
    crate://crates.io/ahash/0.8.9 \
    crate://crates.io/android-tzdata/0.1.1 \
    crate://crates.io/android_system_properties/0.1.5 \
    crate://crates.io/autocfg/1.1.0 \
    crate://crates.io/bitflags/1.3.2 \
    crate://crates.io/bitflags/2.4.2 \
    crate://crates.io/bumpalo/3.16.0 \
    crate://crates.io/cc/1.0.94 \
    crate://crates.io/cfg-if/1.0.0 \
    crate://crates.io/chrono/0.4.38 \
    crate://crates.io/core-foundation-sys/0.8.6 \
    crate://crates.io/crossbeam-channel/0.5.11 \
    crate://crates.io/crossbeam-deque/0.8.5 \
    crate://crates.io/crossbeam-epoch/0.9.18 \
    crate://crates.io/crossbeam-utils/0.8.19 \
    crate://crates.io/crossterm/0.25.0 \
    crate://crates.io/crossterm/0.27.0 \
    crate://crates.io/crossterm_winapi/0.9.1 \
    crate://crates.io/cursive/0.20.0 \
    crate://crates.io/cursive_buffered_backend/0.6.1 \
    crate://crates.io/cursive_core/0.3.7 \
    crate://crates.io/darling/0.20.8 \
    crate://crates.io/darling_core/0.20.8 \
    crate://crates.io/darling_macro/0.20.8 \
    crate://crates.io/deranged/0.3.11 \
    crate://crates.io/either/1.10.0 \
    crate://crates.io/enum-map-derive/0.17.0 \
    crate://crates.io/enum-map/2.7.3 \
    crate://crates.io/enumset/1.1.3 \
    crate://crates.io/enumset_derive/0.8.1 \
    crate://crates.io/fnv/1.0.7 \
    crate://crates.io/getrandom/0.2.12 \
    crate://crates.io/iana-time-zone-haiku/0.1.2 \
    crate://crates.io/iana-time-zone/0.1.60 \
    crate://crates.io/ident_case/1.0.1 \
    crate://crates.io/itoa/1.0.10 \
    crate://crates.io/js-sys/0.3.69 \
    crate://crates.io/lazy_static/1.4.0 \
    crate://crates.io/libc/0.2.153 \
    crate://crates.io/lock_api/0.4.11 \
    crate://crates.io/log/0.4.20 \
    crate://crates.io/mio/0.8.10 \
    crate://crates.io/ntapi/0.4.1 \
    crate://crates.io/num-complex/0.4.5 \
    crate://crates.io/num-conv/0.1.0 \
    crate://crates.io/num-integer/0.1.46 \
    crate://crates.io/num-iter/0.1.44 \
    crate://crates.io/num-rational/0.4.1 \
    crate://crates.io/num-traits/0.2.18 \
    crate://crates.io/num/0.4.1 \
    crate://crates.io/num_threads/0.1.7 \
    crate://crates.io/once_cell/1.19.0 \
    crate://crates.io/owning_ref/0.4.1 \
    crate://crates.io/parking_lot/0.12.1 \
    crate://crates.io/parking_lot_core/0.9.9 \
    crate://crates.io/powerfmt/0.2.0 \
    crate://crates.io/proc-macro2/1.0.78 \
    crate://crates.io/quote/1.0.35 \
    crate://crates.io/rayon-core/1.12.1 \
    crate://crates.io/rayon/1.9.0 \
    crate://crates.io/redox_syscall/0.4.1 \
    crate://crates.io/scopeguard/1.2.0 \
    crate://crates.io/serde/1.0.197 \
    crate://crates.io/serde_derive/1.0.197 \
    crate://crates.io/signal-hook-mio/0.2.3 \
    crate://crates.io/signal-hook-registry/1.4.1 \
    crate://crates.io/signal-hook/0.3.17 \
    crate://crates.io/smallvec/1.13.1 \
    crate://crates.io/stable_deref_trait/1.2.0 \
    crate://crates.io/subprocess/0.2.9 \
    crate://crates.io/syn/2.0.51 \
    crate://crates.io/sysinfo/0.30.7 \
    crate://crates.io/termios/0.3.3 \
    crate://crates.io/time-core/0.1.2 \
    crate://crates.io/time-macros/0.2.17 \
    crate://crates.io/time/0.3.34 \
    crate://crates.io/unicode-ident/1.0.12 \
    crate://crates.io/unicode-segmentation/1.11.0 \
    crate://crates.io/unicode-width/0.1.11 \
    crate://crates.io/version_check/0.9.4 \
    crate://crates.io/wasi/0.11.0+wasi-snapshot-preview1 \
    crate://crates.io/wasm-bindgen-backend/0.2.92 \
    crate://crates.io/wasm-bindgen-macro-support/0.2.92 \
    crate://crates.io/wasm-bindgen-macro/0.2.92 \
    crate://crates.io/wasm-bindgen-shared/0.2.92 \
    crate://crates.io/wasm-bindgen/0.2.92 \
    crate://crates.io/winapi-i686-pc-windows-gnu/0.4.0 \
    crate://crates.io/winapi-x86_64-pc-windows-gnu/0.4.0 \
    crate://crates.io/winapi/0.3.9 \
    crate://crates.io/windows-core/0.52.0 \
    crate://crates.io/windows-sys/0.48.0 \
    crate://crates.io/windows-targets/0.48.5 \
    crate://crates.io/windows-targets/0.52.4 \
    crate://crates.io/windows/0.52.0 \
    crate://crates.io/windows_aarch64_gnullvm/0.48.5 \
    crate://crates.io/windows_aarch64_gnullvm/0.52.4 \
    crate://crates.io/windows_aarch64_msvc/0.48.5 \
    crate://crates.io/windows_aarch64_msvc/0.52.4 \
    crate://crates.io/windows_i686_gnu/0.48.5 \
    crate://crates.io/windows_i686_gnu/0.52.4 \
    crate://crates.io/windows_i686_msvc/0.48.5 \
    crate://crates.io/windows_i686_msvc/0.52.4 \
    crate://crates.io/windows_x86_64_gnu/0.48.5 \
    crate://crates.io/windows_x86_64_gnu/0.52.4 \
    crate://crates.io/windows_x86_64_gnullvm/0.48.5 \
    crate://crates.io/windows_x86_64_gnullvm/0.52.4 \
    crate://crates.io/windows_x86_64_msvc/0.48.5 \
    crate://crates.io/windows_x86_64_msvc/0.52.4 \
    crate://crates.io/xi-unicode/0.3.0 \
    crate://crates.io/zerocopy-derive/0.7.32 \
    crate://crates.io/zerocopy/0.7.32 \
"



# FIXME: update generateme with the real MD5 of the license file
LIC_FILES_CHKSUM = " \
    "

SUMMARY = "xoros-rescue-shell"
HOMEPAGE = "https://github.com/xoros-repo/xoros-rescue-shell"
LICENSE = "CLOSED"

# includes this file if it exists but does not fail
# this is useful for anything you may want to override from
# what cargo-bitbake generates.
include xoros-rescue-shell-${PV}.inc
include xoros-rescue-shell.inc
